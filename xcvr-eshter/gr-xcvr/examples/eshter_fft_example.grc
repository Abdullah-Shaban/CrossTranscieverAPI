<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>eshter_fft_example</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vect_size</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>vect_size</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>n</key><value>10</value></param>
<param><key>k</key><value>0</value></param>
<param><key>vlen</key><value>vect_size</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>fft_size</key><value>vect_size</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(vect_size)</value></param>
<param><key>shift</key><value>True</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>f_c</value></param>
<param><key>label</key><value>Frequency (Hz)</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>700e6</value></param>
</block>
<block>
<key>xcvr_eshter</key>
<param><key>id</key><value>xcvr_eshter_0</value></param>
<param><key>device_path</key><value>/dev/ttyUSB0</value></param>
<param><key>frequency</key><value>f_c</value></param>
<param><key>preset_id</key><value>2</value></param>
<param><key>samples</key><value>vect_size</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>vlen</key><value>vect_size</value></param>
<param><key>x_start</key><value>samp_rate/4./1e3</value></param>
<param><key>x_step</key><value>-samp_rate/vect_size/1e3</value></param>
<param><key>x_axis_label</key><value>Frequency (kHz)</value></param>
<param><key>y_axis_label</key><value>Power (dB)</value></param>
<param><key>x_units</key><value>kHz</value></param>
<param><key>y_units</key><value>dB</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>ymin</key><value>-60</value></param>
<param><key>ymax</key><value>60</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xcvr_eshter_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
